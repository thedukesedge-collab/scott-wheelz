# Keil uVision project ALCM.uvprojx, settings and files
target ALCM (6220000::V6.22::..\..\..\..\..\..\Program Files\ArmCompilerforEmbedded6.22)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ALCM +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lto=1 wLevel=4
  c define: HK32F030M, HK32F030MF4P6, VP_LIGHT_CONTROL
  c include: ..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\HK32F030M_Lib\inc;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\CM0\Core;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\HK32F030M\Include;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M_Project\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\battery_lut.sct
  group Startup
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/ARM/: KEIL_Startup_hk32f030m.s
  group src
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M_Project/src/: hk32f030m_it.c main.c event_queue.c timer.c button_driver.c button_events.c board_mode.c power.c power_hw.c buzzer.c tim1.c headlights.c buzzer_hw.c footpads.c footpads_hw.c status_leds.c status_leds_hw.c headlights_hw.c ws2812.s button_driver_hw.c vesc_serial.c vesc_serial_hw.c battery_lut.c battery_lut_hw.c ring_buffer.c crc16_ccitt.c animations.c settings.c eeprom.c command_processor.c function_generator.c hysteresis.c interrupts_hw.c
  group lib
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/: system_hk32f030m.c
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/HK32F030M_Lib/src/: hk32f030m_rcc.c hk32f030m_gpio.c hk32f030m_exti.c hk32f030m_misc.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_adc.c hk32f030m_usart.c hk32f030m_flash.c
